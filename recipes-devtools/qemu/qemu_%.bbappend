CFLAGS:append:mingw32 = " -Wno-error=incompatible-pointer-types"
