PACKAGECONFIG:remove:mingw32 = "tools"
